# Keil uVision project CX_NFC_RX.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32C231F8 GigaDevice
  pack: GigaDevice.GD32C2x1_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0003000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: CX_NFC_RX +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\std\GD32C2x1_Firmware_Library\CMSIS\GD\GD32C2x1\Include;..\std\GD32C2x1_Firmware_Library\GD32C2x1_standard_peripheral\Include;..\app;..\bsp;..\drv
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group app
    ../app/: main.c gd32c2x1_it.c nfc_command.c filter.c hns_ntc.c
  group bsp
    ../bsp/: bsp_i2c.c bsp_delay.c bsp_gpio.c bsp_adc.c
  group drv
    ../drv/: i2c_bus_device.c fm411_driver.c
  group std/core
    ../std/GD32C2x1_Firmware_Library/CMSIS/GD/GD32C2x1/Source/ARM/: startup_gd32c2x1.s
    ../std/GD32C2x1_Firmware_Library/CMSIS/GD/GD32C2x1/Source/: system_gd32c2x1.c gd32c2x1_err_report.c
  group std/lib
    ../std/GD32C2x1_Firmware_Library/GD32C2x1_standard_peripheral/Source/: gd32c2x1_adc.c gd32c2x1_cmp.c gd32c2x1_crc.c gd32c2x1_dbg.c gd32c2x1_dma.c gd32c2x1_exti.c gd32c2x1_fmc.c gd32c2x1_fwdgt.c gd32c2x1_gpio.c gd32c2x1_i2c.c gd32c2x1_misc.c gd32c2x1_pmu.c gd32c2x1_rcu.c gd32c2x1_rtc.c gd32c2x1_spi.c gd32c2x1_syscfg.c gd32c2x1_timer.c gd32c2x1_usart.c gd32c2x1_wwdgt.c
software components: CMSIS:CORE 5.5.0
